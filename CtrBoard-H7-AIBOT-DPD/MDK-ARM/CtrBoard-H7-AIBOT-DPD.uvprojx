# Keil uVision project CtrBoard-H7-AIBOT-DPD.uvprojx, settings and files
target CtrBoard-H7-AIBOT-DPD (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7-AIBOT-DPD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY,ARM_MATH_CM7
  c include: ../Core/Inc;../App/Inc;../BSP/Inc;../Middleware/Filter/Inc;../Middleware/Protocol/Inc;../Middleware/Motor/Inc;../Middleware/RobStride/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../DSP/Include;../DSP/PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/App
    ../App/Src/: app_led_indicator.c app_ld2rs_task.c app_chassis_motor_ctrl.c app_steer_chassis.c app_wheel_task.c app_serial_ctrl.c
  group BSP
    ../BSP/Src/: bsp_can_robostride.c bsp_rs485.c bsp_vofa.c bsp_rc.c bsp_ws4810.c bsp_rs485_bus2.c bsp_serial_protocol.c bsp_dwt.c
  group Middleware/Filter
    ../Middleware/Filter/Src/: low_pass_filter.c
  group Middleware/Protocol
    ../Middleware/Protocol/Src/: modbus_rtu.c
  group Middleware/Motor
    ../Middleware/Motor/Src/: ld2_motor.c ds_rs_um_motor.c
  group Middleware/RobStride
    ../Middleware/RobStride/Src/: robstride_motor.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group DSP
    ../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../DSP/Source/WindowFunctions/: WindowFunctions.c
software components: CMSIS:CORE 6.2.0
